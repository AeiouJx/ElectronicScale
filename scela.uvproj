# Keil uVision project scela.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: scela +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: app.c HX711.c key.c lcd.c main.c timer0.c uart.c
